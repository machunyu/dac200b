# IAR project Doorlock.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Nano100AN series Nuvoton Nano100AN series (Nano100AN,Nano110AN,Nano120AN,Nano130AN)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\inc; ..\..\Library\CMSIS\Include; ..\..\Library\Device\Nuvoton\Nano100Series\Include; ..\..\Library\StdDriver\inc; ..\..\Drivers\hs_delay; ..\..\Drivers\hs_alarm; ..\..\Drivers\hs_keyboard; ..\..\Drivers\hs_adc; ..\..\Drivers\hs_audio; ..\..\Drivers\hs_beep; ..\..\Drivers\hs_lcd; ..\..\Drivers\hs_led; ..\..\Drivers\hs_key; ..\..\Drivers\hs_timer; ..\..\Drivers\hs_debug; ..\..\Drivers\hs_power; ..\..\Drivers\hs_detect; ..\..\Drivers\hs_usart; ..\..\Drivers\hs_iwdg; ..\..\Drivers\hs_door; ..\..\Drivers\hs_flash; ..\..\Drivers\hs_rc523; ..\..\Drivers\hs_systick; ..\..\Drivers\hs_beat; ..\..\Drivers\hs_a33io
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Doorlock.hex
  ILINK.IlinkOutputFile: Doorlock.out
  ILINK.IlinkIcfFile: Doorlock.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\CONFIG\generic_cortex.icf
  group Application/EWARM
    ../../Library/Device/Nuvoton/Nano100Series/Source/IAR/: startup_Nano100Series.s
  group Application/User
    ../src/: hs_card_manager.c hs_door_control.c hs_event.c hs_heart_beat.c hs_module.c hs_msg_process.c hs_poll.c hs_status.c hs_sys_mgr.c hs_timer_list.c main.c NT32nano100a_it.c
  group Drivers/BSP/hs_a33io
    ../../Drivers/hs_a33io/: hs_a33io.c hs_a33io.h
  group Drivers/BSP/hs_beep
    ../../Drivers/hs_beep/: hs_beep.c hs_beep.h
  group Drivers/BSP/hs_debug
    ../../Drivers/hs_debug/: hs_debug.c hs_debug.h
  group Drivers/BSP/hs_delay
    ../../Drivers/hs_delay/: hs_delay.c hs_delay.h
  group Drivers/BSP/hs_detect
    ../../Drivers/hs_detect/: hs_detect.c hs_detect.h
  group Drivers/BSP/hs_door
    ../../Drivers/hs_door/: hs_door.c hs_door.h
  group Drivers/BSP/hs_flash
    ../../Drivers/hs_flash/: hs_flash.c hs_flash.h
  group Drivers/BSP/hs_iwdg
    ../../Drivers/hs_iwdg/: hs_iwdg.c hs_iwdg.h
  group Drivers/BSP/hs_key
    ../../Drivers/hs_key/: hs_key.c hs_key.h
  group Drivers/BSP/hs_keyboard
    ../../Drivers/hs_keyboard/: hs_keyboard.c hs_keyboard.h key_iic.c key_iic.h key_led.c key_led.h
  group Drivers/BSP/hs_lcd
    ../../Drivers/hs_lcd/: hs_lcd.c hs_lcd.h
  group Drivers/BSP/hs_led
    ../../Drivers/hs_led/: hs_led.c hs_led.h
  group Drivers/BSP/hs_power
    ../../Drivers/hs_power/: hs_power.c hs_power.h
  group Drivers/BSP/hs_rc523
    ../../Drivers/hs_rc523/: hs_rc523.c hs_rc523.h hs_rc523_api.c hs_rc523_api.h hs_rc523_spi.c hs_rc523_spi.h
  group Drivers/BSP/hs_systick
    ../../Drivers/hs_systick/: hs_systick.c hs_systick.h
  group Drivers/BSP/hs_timer
    ../../Drivers/hs_timer/: hs_timer.c hs_timer.h
  group Drivers/BSP/hs_usart
    ../../Drivers/hs_usart/: hs_protocol.c hs_protocol.h hs_usart.c hs_usart.h
  group Drivers/CMSIS
    ../../Library/Device/Nuvoton/Nano100Series/Source/: system_Nano100Series.c
  group Drivers/NT32_StdPeriph_Driver
    ../../Library/StdDriver/src/: adc.c clk.c fmc.c gpio.c i2c.c pdma.c retarget.c rtc.c sc.c spi.c sys.c timer.c uart.c wdt.c
